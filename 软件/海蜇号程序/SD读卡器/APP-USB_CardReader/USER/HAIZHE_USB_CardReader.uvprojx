# Keil uVision project HAIZHE_USB_CardReader.uvprojx, settings and files
target HAIZHE_USB_CardReader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HAIZHE_USB_CardReader +hex
  AfterMake: E:\Program\MDK\ARM\ARMCC\bin\fromelf.exe --bin -o  .\Objects\HAIZHE_USB_CardReader.bin  .\Objects\HAIZHE_USB_CardReader.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx,USE_USB_OTG_FS
  c include: ..\CORE;..\USER;..\HALLIB\STM32F4xx_HAL_Driver\Inc;..\HARDWARE\FLASH;..\LIB;..\SYSTEM;..\LIB\uart;..\LIB\usart;..\HARDWARE\LED;..\HARDWARE\SDCARD;..\MALLOC;..\LIB\delay;..\LIB\sys;..\LIB\timer;..\FATFS\exfuns;..\FATFS\src;..\FATFS\src\option;..\USB\USB_APP;..\USB\STM32_USB_OTG_Driver\inc;..\USB\STM32_USB_Device_Library\Core\inc;..\USB\STM32_USB_Device_Library\Class\msc\inc;..\HARDWARE\Flash;..\LIB\spi
  library: MicroLIB
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c system.c
  group CORE
    ../CORE/: cmsis_armcc.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f427xx.s
  group HALLIB
    ../HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_sd.c stm32f4xx_ll_sdmmc.c
  group SYSTEM
    ../SYSTEM/: stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SDCARD/: sdio_sdcard.c
    ../HARDWARE/Flash/: flash.c flash_w25qxx.c
  group DOC
    ../DOC/: readme.txt reference.txt bug.txt record.txt TODO.txt
  group LIB
    ../LIB/spi/: spi.c
    ../LIB/uart/: uart.c
    ../LIB/adc/: adc.c
    ../LIB/delay/: delay.c
    ../LIB/sys/: sys.c
    ../LIB/timer/: timer.c
    ../LIB/matrix/: MathWrapper.cpp
    ../LIB/pid/: pid.c
    ../LIB/math/: LowPassFilter.c mymath.c
    ../LIB/cJson/cJSON-master/: cJSON.c cJSON_Utils.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/src/option/: cc936.c
  group USB_OTG
    ../USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_DEVICE
    ../USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../USB/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group USB_APP
    ../USB/USB_APP/: usb_bsp.c usbd_desc.c usbd_storage_msd.c usbd_usr.c
