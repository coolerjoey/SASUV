# Keil uVision project HAIZHE_V2_0_HAL.uvprojx, settings and files
target HAIZHE_V2_0_HAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HAIZHE_V2_0_HAL +hex
  AfterMake: E:\Program\MDK\ARM\ARMCC\bin\fromelf.exe --bin -o  .\Objects\Haizhe.bin  .\Objects\HAIZHE_V2_0_HAL.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CORE;..\USER;..\HALLIB\STM32F4xx_HAL_Driver\Inc;..\HARDWARE\FLASH;..\LIB;..\SYSTEM;..\LIB\adc;..\LIB\iic;..\LIB\spi;..\LIB\uart;..\LIB\usart;..\HARDWARE\LED;..\LIB\adc;..\HARDWARE\SDCARD;..\MODULES\MALLOC;..\LIB\delay;..\LIB\sys;..\LIB\timer;..\HARDWARE\SERVO;..\HARDWARE\RELAY;..\HARDWARE\TELEM;..\HARDWARE\BAROMETER;..\HARDWARE\AHRS;..\HARDWARE\MOTORS;..\LIB\matrix;..\HARDWARE\CONTROLLER;..\LIB\pid;..\LIB\math;..\MODULES\FATFS\exfuns;..\MODULES\FATFS\src;..\MODULES\FATFS\src\option;..\HARDWARE\ANO_COM;..\MODULES\MAVLINK;..\MODULES\MAVLINK\common;..\HARDWARE\ws;..\HARDWARE\PPM;..\HARDWARE\GPS;..\HARDWARE\Camera;..\LIB\PID_V1;..\LIB\rtc;..\MODULES\USB\USB_APP;..\MODULES\USB\STM32_USB_OTG_Driver\inc;..\MODULES\USB\STM32_USB_Device_Library\Core\inc;..\MODULES\USB\STM32_USB_Device_Library\Class\cdc\inc;..\MODULES\LOGGER;..\MODULES\MODEL;..\MODULES\MISSION;..\MODULES\WPNAV;..\HARDWARE\Ethernet\Internet;..\HARDWARE\Ethernet\W5500;..\MODULES\KF;..\MODULES\DSP_LIB\Include;..\HARDWARE\EC;..\HARDWARE\IMU
  memory RVCT4: ROM 0x8010000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c parameter.c system.c sensor.c control_mode.c scheduler.c GCS_Common.c GCS_Mavlink.c mode_manual.c mode_auto.c joystick.c test.c console.c mode_stabilize.c mode_althold.c mode_task.c navigation.c commands_logic.c position_vector.c mode_rtl.c mode_surface.c INS.c
  group CORE
    ../CORE/: cmsis_armcc.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f427xx.s
  group HALLIB
    ../HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_sd.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c
  group SYSTEM
    ../SYSTEM/: stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/Flash/: flash.c flash_w25qxx.c
    ../HARDWARE/MOTORS/: motors.c
    ../HARDWARE/SERVO/: servo.c
    ../HARDWARE/TELEM/: telem.c telem_TTL_xG.c
    ../HARDWARE/RELAY/: relay.c
    ../HARDWARE/BAROMETER/: barometer.c baro_av.c
    ../HARDWARE/CONTROLLER/: attitude_controller.c position_controller.c
    ../HARDWARE/SDCARD/: sdio_sdcard.c
    ../HARDWARE/PPM/: ppm.c
    ../HARDWARE/GPS/: gps.c
    ../HARDWARE/Camera/: camera.c
    ../HARDWARE/EC/: EC_TCM.c EC_DDM350B.c EC.c
    ../HARDWARE/IMU/: IMU_JY901.c IMU.c
  group DOC
    ../DOC/: readme.txt reference.txt bug.txt record.txt TODO.txt
  group LIB
    ../LIB/spi/: spi.c
    ../LIB/uart/: uart.c
    ../LIB/adc/: adc.c
    ../LIB/delay/: delay.c
    ../LIB/sys/: sys.c
    ../LIB/timer/: timer.c
    ../LIB/matrix/: MathWrapper.cpp
    ../LIB/pid/: pid.c
    ../LIB/math/: LowPassFilter.c mymath.c
    ../LIB/rtc/: rtc.c
  group MALLOC
    ../MODULES/MALLOC/: malloc.c
  group FATFS
    ../MODULES/FATFS/exfuns/: exfuns.c fattester.c
    ../MODULES/FATFS/src/: diskio.c ff.c
    ../MODULES/FATFS/src/option/: cc936.c
  group LOG
    ../MODULES/LOGGER/: Logger.c
  group MODEL
    ../MODULES/MODEL/: model.c model_verify.c model_test.c
  group WPNAV
    ../MODULES/MISSION/: mission.c
    ../MODULES/KF/: kf.c kf_test.c kf_verify.c
  group ETHERNET
    ../HARDWARE/Ethernet/Internet/: dhcp.c udp_demo.c
    ../HARDWARE/Ethernet/W5500/: socket.c utility.c w5500.c w5500_conf.c
  group DSP_LIB
    ../MODULES/DSP_LIB/Lib/ARM/: arm_cortexM4lf_math.lib
